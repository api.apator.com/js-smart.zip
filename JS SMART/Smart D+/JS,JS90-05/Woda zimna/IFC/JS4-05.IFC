Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS4-05.IFC
Time: 2025-05-23T07:49:04
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 9004-750201.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 9004-750202_zagi_ta.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Liczyd_o.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: NONE (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Part-3116.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Part-3117.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Part-3118.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: szklanka.STEP
In: Default Storey
PredefinedType: ELEMENT; Material: 0
