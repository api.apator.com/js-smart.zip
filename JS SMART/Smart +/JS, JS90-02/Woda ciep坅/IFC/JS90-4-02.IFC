Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS90-4-02.IFC
Time: 2025-06-06T07:13:37
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: NONE (5)
In: Default Storey
PredefinedType: ELEMENT
