Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS90-1.6-02.IFC
Time: 2025-05-23T10:50:54
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 9050-000022-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 9526-060000-1/9526-010700-1/9050-010002-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie2
In: Default Storey
PredefinedType: ELEMENT
