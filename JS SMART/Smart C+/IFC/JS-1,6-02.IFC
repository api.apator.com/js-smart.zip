Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: JS-1,6-02.IFC
Time: 2025-05-23T10:19:05
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 9060-000022-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Wyci¹gniêcie po profilach2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Wyci¹gniêcie po profilach5
In: Default Storey
PredefinedType: ELEMENT
